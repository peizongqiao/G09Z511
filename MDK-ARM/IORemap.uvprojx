# Keil uVision project IORemap.uvprojx, settings and files
target N32G43x (6160000::V6.16::ARMCLANG)
  device: N32G435RB Nationstech
  pack: Nationstech.N32G43x_DFP.0.9.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IORemap +hex
  c flags: Optim=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: N32G43X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32g43x_std_periph_driver\inc;..\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g43x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g43x.c
  group FWLB
    ../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_adc.c n32g43x_can.c n32g43x_comp.c n32g43x_crc.c n32g43x_dac.c n32g43x_dbg.c n32g43x_dma.c n32g43x_exti.c n32g43x_flash.c n32g43x_gpio.c n32g43x_i2c.c n32g43x_iwdg.c n32g43x_lptim.c n32g43x_lpuart.c n32g43x_opamp.c n32g43x_pwr.c n32g43x_rcc.c n32g43x_rtc.c n32g43x_spi.c n32g43x_tim.c n32g43x_tsc.c n32g43x_usart.c n32g43x_wwdg.c
  group USER
    ../src/: main.c n32g43x_it.c
  group driver
    ../driver/: dlp_manager.c d3437.c i2c_master.c n32g43x_start_pins.c bsp_uart.c adc_basic.c bsp_adc.c counter.c PWM.c clkctrl.c app_softtimer.c app_log.c i2c_slave_N32G43X.c bsp_focal_dz24.c app_iris.c app_focal_ctrl.c utils.c bsp_mult_pwm.c bsp_filtermotor_soft_subdivision.c i2c_master_1.c i2c2_slave_N32G43X.c
